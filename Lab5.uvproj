# Keil uVision project Lab5.uvproj, settings and files
target Lab5 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab2
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: .\Include;.\Library
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./Source/: Timer.c Buttons.c Debug.c Lab5_Main.c SPI.c MusicLogic.c Music.c
  group Library
    ./Library/: IO.s LCD.s PLL.c PLL.h Print.s ST7735.c ST7735.h startup.s tm4c123gh6pm.h
  group Include
    ./Include/: Timer.h Buttons.h Debug.h SPI.h Music.h MusicLogic.h
